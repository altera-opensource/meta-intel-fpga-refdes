FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = " file://0001-rar-Fix-double-free-with-over-4-billion-nodes-2598.patch"