FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://Downgrade-a-couple-of-warnings-to-debug.patch"
