FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://0001-mkimage-Use-PATH_MAX-for-path-length.patch"

