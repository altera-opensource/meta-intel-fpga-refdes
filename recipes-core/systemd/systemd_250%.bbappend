FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = "file://Downgrade-a-couple-of-warnings-to-debug.patch"
