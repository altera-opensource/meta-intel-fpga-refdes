FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://249-Downgrade-a-couple-of-warnings-to-debug.patch"
