FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://247-Downgrade-a-couple-of-warnings-to-debug.patch"
