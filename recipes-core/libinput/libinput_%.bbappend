FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = " file://CVE-2026-50292.patch"
