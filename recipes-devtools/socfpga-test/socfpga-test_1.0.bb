require recipes-devtools/socfpga-test/socfpga-test.inc

